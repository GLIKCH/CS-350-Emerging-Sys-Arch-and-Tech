# IAR project gpiointerrupt_CC3220S_LAUNCHXL_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  postbuild: ielftool --bin --verbose $TARGET_BPATH$.out $TARGET_BPATH$.bin
  group (top)
    ./: gpiointerrupt_CC3220S_LAUNCHXL_nortos_iar.ipcf SysConfig_Generated_Files.ipcf
